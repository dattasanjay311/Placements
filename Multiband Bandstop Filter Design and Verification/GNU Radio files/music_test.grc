options:
  parameters:
    author: delta
    generate_options: qt_gui
    id: music_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 65e4
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: '44100'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 63e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-63e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-132e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 132e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /mnt/A8CA236ACA23344A/Collage/DSP/background.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[6.276799e-03,3.098585e-03,1.374327e-03,7.522325e-03,-7.132203e-04,-1.210949e-03,1.986647e-04,-2.534367e-03,7.954589e-04,-1.163334e-02,-9.612593e-03,2.222592e-02,1.384683e-02,-8.552734e-03,2.850948e-03,-1.072727e-02,-2.289081e-02,1.105438e-02,1.747496e-02,-1.880191e-03,2.560340e-04,-9.120678e-05,3.306242e-03,1.696446e-03,-1.695678e-02,-5.000609e-03,2.283070e-03,-8.804631e-03,3.048305e-02,3.328188e-02,-3.337388e-02,-2.657619e-02,4.608627e-03,-1.433374e-02,1.120513e-02,3.200718e-02,-3.787594e-03,-7.539235e-03,2.440586e-05,4.825952e-03,5.631896e-03,-5.207126e-02,-3.045101e-02,6.567994e-02,2.398125e-02,1.540039e-02,6.913022e-02,-1.019605e-01,-1.619750e-01,8.015250e-02,9.126578e-02,3.213145e-03,1.243087e-01,-2.063400e-02,7.538462e-01,-2.063400e-02,1.243087e-01,3.213145e-03,9.126578e-02,8.015250e-02,-1.619750e-01,-1.019605e-01,6.913022e-02,1.540039e-02,2.398125e-02,6.567994e-02,-3.045101e-02,-5.207126e-02,5.631896e-03,4.825952e-03,2.440586e-05,-7.539235e-03,-3.787594e-03,3.200718e-02,1.120513e-02,-1.433374e-02,4.608627e-03,-2.657619e-02,-3.337388e-02,3.328188e-02,3.048305e-02,-8.804631e-03,2.283070e-03,-5.000609e-03,-1.695678e-02,1.696446e-03,3.306242e-03,-9.120678e-05,2.560340e-04,-1.880191e-03,1.747496e-02,1.105438e-02,-2.289081e-02,-1.072727e-02,2.850948e-03,-8.552734e-03,1.384683e-02,2.222592e-02,-9.612593e-03,-1.163334e-02,7.954589e-04,-2.534367e-03,1.986647e-04,-1.210949e-03,-7.132203e-04,7.522325e-03,1.374327e-03,3.098585e-03,6.276799e-03]'
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[6.276799e-03,3.098585e-03,1.374327e-03,7.522325e-03,-7.132203e-04,-1.210949e-03,1.986647e-04,-2.534367e-03,7.954589e-04,-1.163334e-02,-9.612593e-03,2.222592e-02,1.384683e-02,-8.552734e-03,2.850948e-03,-1.072727e-02,-2.289081e-02,1.105438e-02,1.747496e-02,-1.880191e-03,2.560340e-04,-9.120678e-05,3.306242e-03,1.696446e-03,-1.695678e-02,-5.000609e-03,2.283070e-03,-8.804631e-03,3.048305e-02,3.328188e-02,-3.337388e-02,-2.657619e-02,4.608627e-03,-1.433374e-02,1.120513e-02,3.200718e-02,-3.787594e-03,-7.539235e-03,2.440586e-05,4.825952e-03,5.631896e-03,-5.207126e-02,-3.045101e-02,6.567994e-02,2.398125e-02,1.540039e-02,6.913022e-02,-1.019605e-01,-1.619750e-01,8.015250e-02,9.126578e-02,3.213145e-03,1.243087e-01,-2.063400e-02,7.538462e-01,-2.063400e-02,1.243087e-01,3.213145e-03,9.126578e-02,8.015250e-02,-1.619750e-01,-1.019605e-01,6.913022e-02,1.540039e-02,2.398125e-02,6.567994e-02,-3.045101e-02,-5.207126e-02,5.631896e-03,4.825952e-03,2.440586e-05,-7.539235e-03,-3.787594e-03,3.200718e-02,1.120513e-02,-1.433374e-02,4.608627e-03,-2.657619e-02,-3.337388e-02,3.328188e-02,3.048305e-02,-8.804631e-03,2.283070e-03,-5.000609e-03,-1.695678e-02,1.696446e-03,3.306242e-03,-9.120678e-05,2.560340e-04,-1.880191e-03,1.747496e-02,1.105438e-02,-2.289081e-02,-1.072727e-02,2.850948e-03,-8.552734e-03,1.384683e-02,2.222592e-02,-9.612593e-03,-1.163334e-02,7.954589e-04,-2.534367e-03,1.986647e-04,-1.210949e-03,-7.132203e-04,7.522325e-03,1.374327e-03,3.098585e-03,6.276799e-03]'
    type: ccf
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[6.276799e-03,3.098585e-03,1.374327e-03,7.522325e-03,-7.132203e-04,-1.210949e-03,1.986647e-04,-2.534367e-03,7.954589e-04,-1.163334e-02,-9.612593e-03,2.222592e-02,1.384683e-02,-8.552734e-03,2.850948e-03,-1.072727e-02,-2.289081e-02,1.105438e-02,1.747496e-02,-1.880191e-03,2.560340e-04,-9.120678e-05,3.306242e-03,1.696446e-03,-1.695678e-02,-5.000609e-03,2.283070e-03,-8.804631e-03,3.048305e-02,3.328188e-02,-3.337388e-02,-2.657619e-02,4.608627e-03,-1.433374e-02,1.120513e-02,3.200718e-02,-3.787594e-03,-7.539235e-03,2.440586e-05,4.825952e-03,5.631896e-03,-5.207126e-02,-3.045101e-02,6.567994e-02,2.398125e-02,1.540039e-02,6.913022e-02,-1.019605e-01,-1.619750e-01,8.015250e-02,9.126578e-02,3.213145e-03,1.243087e-01,-2.063400e-02,7.538462e-01,-2.063400e-02,1.243087e-01,3.213145e-03,9.126578e-02,8.015250e-02,-1.619750e-01,-1.019605e-01,6.913022e-02,1.540039e-02,2.398125e-02,6.567994e-02,-3.045101e-02,-5.207126e-02,5.631896e-03,4.825952e-03,2.440586e-05,-7.539235e-03,-3.787594e-03,3.200718e-02,1.120513e-02,-1.433374e-02,4.608627e-03,-2.657619e-02,-3.337388e-02,3.328188e-02,3.048305e-02,-8.804631e-03,2.283070e-03,-5.000609e-03,-1.695678e-02,1.696446e-03,3.306242e-03,-9.120678e-05,2.560340e-04,-1.880191e-03,1.747496e-02,1.105438e-02,-2.289081e-02,-1.072727e-02,2.850948e-03,-8.552734e-03,1.384683e-02,2.222592e-02,-9.612593e-03,-1.163334e-02,7.954589e-04,-2.534367e-03,1.986647e-04,-1.210949e-03,-7.132203e-04,7.522325e-03,1.374327e-03,3.098585e-03,6.276799e-03]'
    type: ccf
  states: {}
- name: fir_filter_xxx_0_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[6.276799e-03,3.098585e-03,1.374327e-03,7.522325e-03,-7.132203e-04,-1.210949e-03,1.986647e-04,-2.534367e-03,7.954589e-04,-1.163334e-02,-9.612593e-03,2.222592e-02,1.384683e-02,-8.552734e-03,2.850948e-03,-1.072727e-02,-2.289081e-02,1.105438e-02,1.747496e-02,-1.880191e-03,2.560340e-04,-9.120678e-05,3.306242e-03,1.696446e-03,-1.695678e-02,-5.000609e-03,2.283070e-03,-8.804631e-03,3.048305e-02,3.328188e-02,-3.337388e-02,-2.657619e-02,4.608627e-03,-1.433374e-02,1.120513e-02,3.200718e-02,-3.787594e-03,-7.539235e-03,2.440586e-05,4.825952e-03,5.631896e-03,-5.207126e-02,-3.045101e-02,6.567994e-02,2.398125e-02,1.540039e-02,6.913022e-02,-1.019605e-01,-1.619750e-01,8.015250e-02,9.126578e-02,3.213145e-03,1.243087e-01,-2.063400e-02,7.538462e-01,-2.063400e-02,1.243087e-01,3.213145e-03,9.126578e-02,8.015250e-02,-1.619750e-01,-1.019605e-01,6.913022e-02,1.540039e-02,2.398125e-02,6.567994e-02,-3.045101e-02,-5.207126e-02,5.631896e-03,4.825952e-03,2.440586e-05,-7.539235e-03,-3.787594e-03,3.200718e-02,1.120513e-02,-1.433374e-02,4.608627e-03,-2.657619e-02,-3.337388e-02,3.328188e-02,3.048305e-02,-8.804631e-03,2.283070e-03,-5.000609e-03,-1.695678e-02,1.696446e-03,3.306242e-03,-9.120678e-05,2.560340e-04,-1.880191e-03,1.747496e-02,1.105438e-02,-2.289081e-02,-1.072727e-02,2.850948e-03,-8.552734e-03,1.384683e-02,2.222592e-02,-9.612593e-03,-1.163334e-02,7.954589e-04,-2.534367e-03,1.986647e-04,-1.210949e-03,-7.132203e-04,7.522325e-03,1.374327e-03,3.098585e-03,6.276799e-03]'
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e4
    decim: '1'
    gain: '5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0
    name: '"Original signal with Noise"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    name: '"First upconversion"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@2
    name: '"After First FIR Filter"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@3
    name: '"After First Down Conversion"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@4
    name: '"Second Up Conversion"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_3_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@6
    name: '"Second Down Conversion"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@5
    name: '"After Second FIR"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_5
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@7
    name: '"Final Signal"'
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Original signal with Noise
    label1: First upconversion
    label2: After First FIR Filter
    label3: After First Down Conversion
    label4: Second Up Conversion
    label5: After Second FIR
    label6: Second Down Conversion
    label7: Final Signal
    num_tabs: '8'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: '650000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '650000'
    interp: '44100'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: o2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: o1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: o2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: o1
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_1_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_float_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_freq_sink_x_0_3_0, '0']
- [blocks_multiply_xx_0_1, '0', fir_filter_xxx_0_0_0, '0']
- [blocks_multiply_xx_0_1, '0', qtgui_freq_sink_x_0_3, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_0_0, '0', fir_filter_xxx_0_1, '0']
- [fir_filter_xxx_0_0_0, '0', fir_filter_xxx_0_1_0, '0']
- [fir_filter_xxx_0_1, '0', blocks_multiply_xx_0_0, '1']
- [fir_filter_xxx_0_1, '0', qtgui_freq_sink_x_0_1, '0']
- [fir_filter_xxx_0_1_0, '0', blocks_multiply_xx_0_0_0, '1']
- [fir_filter_xxx_0_1_0, '0', qtgui_freq_sink_x_0_4, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0_5, '0']
- [rational_resampler_xxx_1, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_1, '1']
- [virtual_source_1, '0', audio_sink_0_0, '0']
- [virtual_source_1, '0', blocks_null_sink_0, '1']
- [virtual_source_2, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
